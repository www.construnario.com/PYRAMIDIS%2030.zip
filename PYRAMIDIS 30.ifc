Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: C:\Users\Usuario\Desktop\JOMBAR\MUESTRAS B.I.M\BIM\PYRAMIDIS 30.ifc
Time: 2016-12-01T20:10:26
Written by: ACCA_IFC.dll Version 200
Made in: Edificius 8.00c

# IfcSite, Default Site
RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey (4)
In: Default Building
Name | Elevation (mm) | NominalHeight (mm)
TERRENO | -1500 | 1000
Cimentación | -500 | 500
Planta Baja | 0 | 3200
Cubierta | 3200 | 0

# IfcFurnishingElement: SEPARADOR, PY030
In: Planta Baja
Description: PYRAMIDIS 30; Material: Color_01
PROPIEDADES TÉRMICAS - TEMPERATURA H.D.T.: 74º C
PROPIEDADES GENERALES - DENSIDAD: 905 Kg/m3 (ISO 1183); TEMPERATURA MÁXIMA ALMACENAMIENTO: 60º C; RESISTENCIA QUÍMICA: ÁCIDOS, ÁLCALIS Y DISOLVENTES; RADIACIÓN ULTRAVIOLETA: BUENO; COLOR STANDARD: GRIS; COMPOSICIÓN: POLIPROPILENO; PESO POR UNIDAD: 2,9 g
Pset_ManufacturerTypeInformation - ArticleNumber: PYRAMIDIS; ModelReference: PY030; ModelLabel: PY030; Manufacturer: JOMBAR; ProductionYear: 2016
PROPIEDADES MECÁNICAS - MÓDULO ELÁSTICO EN FLEXIÓN: 1100 MPa (ISO 178); RESISTENCIA AL IMPACTO CHARPY (23º C CON ENTALLA): 12 KJ/m2 (ISO 179); IMPACTO IZOD (23º CON MUESCA): 11 KJ/m2 (ISO 180); IMPACTO IZOD (-20º SIN MUESCA): 60 KJ/m2 (ISO 527-1); DUREZA SHORE D: 60 ESCALA D (ISO 868); CARGA MÁXIMA POR PIEZA: 20 Kg (NO CAMINAR SOBRE ARMADURA)
